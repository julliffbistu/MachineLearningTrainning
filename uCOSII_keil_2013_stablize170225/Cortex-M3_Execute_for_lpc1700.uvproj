# Keil uVision project Cortex-M3_Execute_for_lpc1700.uvproj, settings and files
target DebugInFlash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Cortex-M3 Execute for lpc1700 +hex
  c flags: Optim=1
  c define: DEBUG
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\cfg_file\Startup\InChip.sct
  link misc: --entry __main
  group USER_CODE
    ./USER_CODE/: main.c COM_packet.h com_protocol.c transplant.h uart_driver.c main.h DXL_packet.h dxl_protocol.c flash_driver.c adc_driver.c signal_manage.c sensor_processor.c fast_math.c flash_filesystem.c fast_kinematics.c gait_generate.c i2c_driver.c
    ./USER_CODE/ahrs/: matrix.c realDcm.c vector.c
  group ZY_CODE
    ./ZY_CODE/Startup/: LPC1700PinCfg.c target.c vector_table.c lpc1700.h target.h
    ./ZY_CODE/: firmware.h
    ./ZY_CODE/zy_if/: zy_if.c zy_if.h
  group cfg_file
    ./: config.h
    ./cfg_file/: target_cfg.h
    ./cfg_file/Startup/: LPC1700PinCfg.h rt_sys_s.s rt_sys_c.c vector_cfg.h
    ./cfg_file/zy_if/: zy_if_cfg.h
    ./cfg_file/uCOSII/: OS_CFG.H
  group uCOS-II
    ./ZY_CODE/uCOS-II/: OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C uCOS_II.H INCLUDES.H OS_CORE.C OS_FLAG.C
    ./ZY_CODE/uCOS-II/cpu/: os_cpu.h Os_cpu_c.c
    ./ZY_CODE/uCOS-II/hook/: uCOS-II hook.lib
target Release (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: Cortex-M3 Execute for lpc1700 +hex
  c flags: Optim=1
  c define: RELEASE
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\cfg_file\Startup\InChip.sct
  link misc: --entry __main
